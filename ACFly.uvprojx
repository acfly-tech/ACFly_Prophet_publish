# Keil uVision project ACFly.uvprojx, settings and files
target Target 1 (6190000::V6.19::.\ArmCompilerforEmbedded6.19)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ACFly_Prophet +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,__FPU_PRESENT=1,DCACHE_SIZE=32
  c misc: -fno-finite-math-only
  c include: .\Basic;.\Main;.\CMSIS;.\HAL_Library\inc;.\Drivers;.\Drivers\hardware;.\Drivers\sensors;.\Drivers\sensors\imu;.\Drivers\sensors\gps;.\Drivers\sensors\gps\uart;.\Drivers\sensors\avoidance;.\Drivers\sensors\avoidance\can;.\Drivers\sensors\avoidance\uart;.\Drivers\sensors\avoidance\i2c;.\Drivers\diskio;.\Drivers\middleWare\FreeRTOS\include;.\Drivers\middleWare\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;.\Drivers\middleWare\FreeRTOS\CMSIS_RTOS;.\Drivers\middleWare\littlefs;.\Drivers\middleWare\fatfs\src;.\Drivers\middleWare\fatfs\src\option;.\Drivers\middleWare\cherryusb;.\Drivers\middleWare\cherryusb\core;.\Drivers\middleWare\cherryusb\class\hub;.\Drivers\middleWare\cherryusb\class\cdc;.\Drivers\middleWare\cherryusb\class\hid;.\Drivers\middleWare\cherryusb\class\msc;.\Drivers\middleWare\cherryusb\common;.\Drivers\middleWare\cherryusb\port\dwc2;.\Drivers\middleWare\cherryusb\osal;.\Drivers\receiver;.\Drivers\receiver\analog;.\Drivers\receiver\uart;.\Drivers\extIO;.\Drivers\extIO\can;.\Drivers\functions;.\Math;.\CMSIS\DSP\Include;.\Communication;.\MeasurementSystem;.\Filters;.\DataStructure;.\Communication\Mavlink;.\Communication\Mavlink\acfly;.\ControlSystem;.\Communication\Mavlink\minimal;.\Modes;.\Modes\FlightModes;.\Modes\FlightModes\FlightModules;.\Drivers\sensors\altimeter;.\Drivers\sensors\altimeter\can;.\Drivers\sensors\altimeter\uart;.\Drivers\sensors\altimeter\i2c;.\Drivers\sensors\forwardDist;.\Drivers\sensors\forwardDist\uart;.\Drivers\bms;.\Drivers\bms\can;.\Drivers\engine;.\Drivers\engine\can;.\Drivers\engine\uart;.\Drivers\gimbal;.\Drivers\gimbal\can;.\Drivers\gimbal\uart;.\Drivers\led;.\Drivers\led\can;.\Drivers\led\i2c;.\Drivers\sensors\opticalFlow;.\Drivers\sensors\opticalFlow\uart;.\Drivers\sensors\compass;.\Drivers\sensors\compass\i2c;.\Drivers\sensors\precLand;.\Drivers\sensors\precLand\i2c;.\Drivers\sensors\precLand\uart;.\Drivers\sensors\uwb;.\Drivers\sensors\uwb\uart;.\Drivers\remoteid;.\Drivers\remoteid\dronecan_remoteid;.\Drivers\remoteid\dronecan_remoteid\include;.\Drivers\extIO\uart;.\Drivers\osd;.\Drivers\osd\analog;.\Drivers\osd\msp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Objects\ACFly_Prophet.sct
  group Main
    ./Main/: main.cpp semihosting_stubs.c
  group Basic
    ./Basic/: Parameters.hpp StorageSystem.hpp Missions.hpp Basic.cpp TimeBase.cpp InternalStorage.cpp SDStorage.cpp HardWareConfig.cpp Parameters.cpp Missions.cpp Fences.cpp sha256.c precLand.cpp followTarget.cpp forwardDist.cpp Parachute.hpp Parachute.cpp
  group Startup
    ./startup/: startup_stm32h743xx.s
  group CMSIS
    ./CMSIS/: system_stm32h7xx.c
  group HAL_Library
    ./HAL_Library/src/: stm32h7xx_hal.c stm32h7xx_hal_msp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_ll_usb.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_fdcan.c
    ./HAL_Library/inc/: stm32h7xx_hal_conf.h
  group Drivers
    ./Drivers/: drv_Main.cpp
  group Drivers\hardware
    ./Drivers/hardware/: drv_LED.cpp drv_SDMMC.cpp drv_USB.cpp drv_Uart.cpp drv_Flash.cpp drv_can.cpp drv_PWMOut.cpp drv_ADC.cpp drv_CRC.cpp dma.cpp drv_spi.cpp drv_i2c.cpp
    ./Drivers/: drv_SDI.cpp
  group Drivers\middleWare\FreeRTOS
    ./Drivers/middleWare/FreeRTOS/: croutine.c event_groups.c list.c queue.c static_mem.c stream_buffer.c tasks.c timers.c cpu_load.cpp
    ./Drivers/middleWare/FreeRTOS/portable/MemMang/: heap_4.c
    ./Drivers/middleWare/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    ./Drivers/middleWare/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Drivers\middleWare\littlefs
    ./Drivers/middleWare/littlefs/: lfs.c lfs_util.c
  group Drivers\middleWare\fatfs
    ./Drivers/middleWare/fatfs/src/: bsp_driver_sd.c fatfs.c ff.c ff_gen_drv.c ffsystem.c ffunicode.c
  group Drivers\middleWare\cherryusb
    ./Drivers/middleWare/cherryusb/core/: usbd_core.c
    ./Drivers/middleWare/cherryusb/class/cdc/: usbd_cdc.c
    ./Drivers/middleWare/cherryusb/class/hid/: usbd_hid.c
    ./Drivers/middleWare/cherryusb/class/msc/: usbd_msc.c
    ./Drivers/middleWare/cherryusb/osal/: usb_osal_freertos.c
    ./Drivers/middleWare/cherryusb/port/dwc2/: usb_glue_st.c usb_dc_dwc2.c
    ./Drivers/middleWare/cherryusb/: cdc_acm_hid_msc.c
  group Drivers\sensors
    ./Drivers/sensors/: Sensors.cpp
  group Drivers\sensors\imu
    ./Drivers/sensors/imu/: drv_imu.cpp drv_imuDrv_bmi088.cpp drv_imuDrv_icm20689.cpp drv_imuDrv_spl06.cpp drv_imuDrv_icm40609.cpp drv_imuDrv_ak8975.cpp
  group Drivers\sensors\gps
    ./Drivers/sensors/gps/: drv_GPS.cpp
  group Drivers\sensors\gps\uart
    ./Drivers/sensors/gps/uart/: drv_GPS1_NMEA.cpp drv_GPS1_MosaicG5.cpp drv_GPS1_MosaicX5.cpp drv_GPS1_MosaicX6.cpp drv_GPS1_Ublox.cpp drv_GPS1_UbloxBase.cpp drv_GPS1_UbloxM10.cpp drv_GPS1_UM482.cpp drv_GPS1_UM982.cpp drv_GPS1_UM982Base.cpp drv_GPS1_UM982Track.cpp drv_GPS2_UbloxMobile.cpp drv_RTCMSd.cpp drv_RTCMInput.cpp
  group Drivers\sensors\altimeter
    ./Drivers/sensors/altimeter/: drv_Altimeter.cpp drv_Alt1_Ultrasonic_TE.cpp
  group Drivers\sensors\altimeter\can
    ./Drivers/sensors/altimeter/can/: drv_Alt1_TR60_C.cpp drv_Alt1_NRA24_C.cpp
  group Drivers\sensors\altimeter\uart
    ./Drivers/sensors/altimeter/uart/: drv_Alt1_NRA24_U.cpp drv_Alt1_TFMini_U.cpp drv_Alt1_US100_U.cpp
  group Drivers\sensors\altimeter\i2c
    ./Drivers/sensors/altimeter/i2c/: drv_Alt1_SPL06_I.cpp drv_Alt1_TFMini_I.cpp
  group Drivers\sensors\forwardDist
    ./Drivers/sensors/forwardDist/: drv_ForwardDist.cpp
  group Drivers\sensors\forwardDist\uart
    ./Drivers/sensors/forwardDist/uart/: drv_frDist_TonRainU.cpp
  group Drivers\sensors\avoidance
    ./Drivers/sensors/avoidance/: drv_Avoidance.cpp
  group Drivers\sensors\avoidance\can
    ./Drivers/sensors/avoidance/can/: drv_avoidance_MR72_C.cpp
  group Drivers\sensors\avoidance\uart
    ./Drivers/sensors/avoidance/uart/: drv_avoidance_TFMini_U.cpp drv_avoidance_MR72_U.cpp
  group Drivers\sensors\avoidance\i2c
    ./Drivers/sensors/avoidance/i2c/: drv_avoidance_TFMini_I.cpp
  group Drivers\sensors\opticalFlow
    ./Drivers/sensors/opticalFlow/: drv_OpticalFlow.cpp
  group Drivers\sensors\opticalFlow\uart
    ./Drivers/sensors/opticalFlow/uart/: drv_opticalFlow_GL9306_U.cpp drv_opticalFlow_JL32xx_U.cpp drv_opticalFlow_LC302_U.cpp drv_opticalFlow_LC306_U.cpp drv_opticalFlow_T1_T2_U.cpp
  group Drivers\sensors\compass
    ./Drivers/sensors/compass/: drv_Compass.cpp
  group Drivers\sensors\compass\i2c
    ./Drivers/sensors/compass/i2c/: drv_compass_InternalMag_I.cpp drv_compass_ExtMag_I.cpp
  group Drivers\sensors\precLand
    ./Drivers/sensors/precLand/: drv_PrecLand.cpp
  group Drivers\sensors\precLand\i2c
    ./Drivers/sensors/precLand/i2c/: drv_precLand_IRLock_I.cpp
  group Drivers\sensors\precLand\uart
    ./Drivers/sensors/precLand/uart/: drv_precLand_AprilTag_U.cpp
  group Drivers\sensors\uwb
    ./Drivers/sensors/uwb/: drv_UWB.cpp
  group Drivers\sensors\uwb\uart
    ./Drivers/sensors/uwb/uart/: drv_uwb_LinkTrack_U.cpp
  group Drivers\diskio
    ./Drivers/diskio/: sd_diskio.c sdInt_diskio.c flash_diskio.c diskio.c
  group Drivers\receiver
    ./Drivers/receiver/: Receiver.cpp drv_receiver.cpp
  group Drivers\receiver\analog
    ./Drivers/receiver/analog/: drv_rc_ppm.cpp
  group Drivers\receiver\uart
    ./Drivers/receiver/uart/: drv_rc_crsf.cpp drv_rc_sbus.cpp drv_rc_sbus2.cpp
  group Drivers\extIO
    ./Drivers/extIO/: drv_ExtIO.cpp drv_extIO_HTL.cpp
  group Drivers\extIO\can
    ./Drivers/extIO/can/: drv_extIO_Expansion_C.cpp drv_extIO_UAVCanESC_C.cpp
  group Drivers\extIO\uart
    ./Drivers/extIO/uart/: drv_extIO_FPVESC_U.cpp
    ./Drivers/extIO/can/: drv_extIO_AuxChannel_C.cpp
  group drivers\function
    ./Drivers/functions/: drv_Functions.cpp
  group Drivers\gimbal
    ./Drivers/gimbal/: drv_Gimbal.cpp
  group Drivers\gimbal\uart
    ./Drivers/gimbal/uart/: drv_gimbal_SIYI_U.cpp
  group Drivers\remoteid
    ./Drivers/remoteid/: remoteid.lib
  group Drivers\led
    ./Drivers/led/: drv_extLed.cpp
  group Drivers\led\can
    ./Drivers/led/can/: drv_led_ACFly_C.cpp
  group Drivers\led\i2c
    ./Drivers/led/i2c/: drv_led_TCA62724FMG_I.cpp
  group Drivers\osd
    ./Drivers/osd/: drv_OSD.cpp
  group Drivers\osd\analog
    ./Drivers/osd/analog/: drv_osd_analog.cpp
  group Drivers\osd\msp
    ./Drivers/osd/msp/: drv_msp.cpp drv_msp_DisplayPort.cpp drv_msp_DJI_FPV.cpp
  group Math
    ./Math/: AC_Math.hpp vector2.hpp vector3.hpp quaternion.hpp map_projection.hpp smooth_kp.hpp math_common_tables.cpp complex.hpp
  group Communication
    ./Communication/: Commulink.hpp MAVLink_Routing.hpp Debug.cpp Commulink.cpp Mavlink.cpp MavlinkCMDProcess.cpp MavlinkSendFuncs.cpp MavlinkRCProcess.cpp MAVLink_Routing.cpp
  group MeasurementSystem
    ./MeasurementSystem/: MeasurementSystem.hpp MS_Main.cpp MeasurementSystem.lib
  group Filters
    ./Filters/: TD4.hpp TD3_3D.hpp Filters_LP.hpp Filters_BS.hpp
  group DataStructure
    ./DataStructure/: RingQueue.hpp
  group Modes
    ./Modes/: NavCmdProcess.hpp InFlightCmdProcess.hpp Modes.cpp M10_RCCalib.cpp M11_TempCalib.cpp M12_AccCalib.cpp M13_MagCalib.cpp M14_HorizonCalib.cpp M16_GyroAlignCalib.cpp M30_AttCtrl.cpp M32_PosCtrl.cpp MSafe.cpp NavCmdProcess.cpp InFlightCmdProcess.cpp AuxFuncs.cpp Avoidance.cpp
  group Modes\FlightModes
    ./Modes/FlightModes/: FlightMode_AutoMission.cpp FlightMode_Follow.cpp FlightMode_Manual.cpp FlightMode_Mission.cpp FlightMode_OffBoard.cpp FlightMode_PosHold.cpp FlightMode_Circle.cpp FlightMode_TakeOff.cpp FlightMode_RTL.cpp FlightMode_TrajectoryReplay.cpp FlightModes.cpp
  group Modes\FlightModes\FlightModules
    ./Modes/FlightModes/FlightModules/: FlightModule_RecordTrajectory.cpp
  group ControlSystem
    ./ControlSystem/: ControlSystem.hpp ESO_AngularRate.hpp ESO_h.hpp ctrl_Main.cpp Ctrl_Attitude.cpp ctrl_Position.cpp
